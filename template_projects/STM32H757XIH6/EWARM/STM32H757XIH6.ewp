# IAR project STM32H757XIH6.ewp, settings and files
configuration STM32H757XIH6_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H757XI_CM4 ST STM32H757XI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H757xx; USE_PWR_EXTERNAL_SOURCE_SUPPLY
  ICCARM.CCIncludePath2: ../CM4/TouchGFX/App; ../CM4/TouchGFX/target/generated; ../CM4/TouchGFX/target; ../CM4/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32H757XIH6_CM4.hex
  ILINK.IlinkOutputFile: STM32H757XIH6_CM4.out
  ILINK.IlinkIcfFile: stm32h757xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H757XIH6_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H757XI_CM7 ST STM32H757XI_CM7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H757xx; USE_PWR_EXTERNAL_SOURCE_SUPPLY
  ICCARM.CCIncludePath2: ../CM7/USB_DEVICE/App; ../CM7/USB_DEVICE/Target; ../CM7/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: STM32H757XIH6_CM7.hex
  ILINK.IlinkOutputFile: STM32H757XIH6_CM7.out
  ILINK.IlinkIcfFile: stm32h757xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h757xx_CM4.s startup_stm32h757xx_CM7.s
  group Application/User/CM7/USB_DEVICE/Target
    ../CM7/USB_DEVICE/Target/: usbd_conf.c
  group Application/User/CM7/USB_DEVICE/App
    ../CM7/USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM4/TouchGFX/App
    ../CM4/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM4/TouchGFX/target
    ../CM4/TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM4/TouchGFX/target/generated
    ../CM4/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
